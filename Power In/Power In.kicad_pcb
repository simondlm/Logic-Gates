# Repository simondlm/Logic-Gates

File README.md:

# Logic Gate Simulator
 A hardware interpretation of RTL Logic Gates, created in the Eurorack style. 
 
 The project currently has four modules:
 
 ## Power In (Workable)
 This board accepts a standard DC barrel jack and outputs power via pin headers on the reverse of the PCB. 
 The manner of power distribution is simply for convenience whilst testing a suitable input output method
 
 ## Four Power Outlet (Workable)
 This board is a 4-signal output board, to act as inputs for other boards
 
 ## 555 Timer (Workable)
 This board is a controllable oscillator powered by the mighty 555 timer chip in astable mode. The schematic uses a 10k resistor, 100k potentiometer, and 4.7uF capacitor to set a frequency between 'always-on' and approximately 1.5Hz. User choice will be able to change this
 
 ## NOR Gate (Non-working)
 This board acts as a two-input NOR Gate. Current footprinting is incorrect.

## KiCad design Power In/Power In.kicad_pcb

Parts:
D1: LED; LED_D3.0mm
J1: Conn_01x03; PCB_Barrel_Jack
J2: Conn_02x08_Odd_Even; IDC-Header_2x08_P2.54mm_Vertical
R1: R; R_0805_HandSoldering
SW1: SW_SPDT; SPDT Through Hole Switch

Connections:
unnamed: D1.1 (K), J1.3, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16
unnamed: D1.2 (A), R1.2
unnamed: J1.1, SW1.2 (B)
unnamed: J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, R1.1, SW1.1 (A)

Board: 2 copper layers, 27.9 x 27.9 mm, 5 parts (0 on the bottom side), 4 nets.

## KiCad design 555 Timer/555 Timer.kicad_pcb

Parts:
C1: 10nF; C_Disc_D3.0mm_W2.0mm_P2.50mm
C2: 47uF; CP_Radial_D5.0mm_P2.00mm
D1: LED; LED_D3.0mm
J1: Conn_01x02; JST_EH_B02B-EH-A_02x2.50mm_Straight
J2: Conn_01x03; WQP-PJ301M-12_JACK-UPDATE
R1: 10k; R_0805_HandSoldering
R2: 330F; R_0805_HandSoldering
RV1: 100k; Potentiometer_RV09
SW1: SW_SPDT; SPDT Through Hole Switch
U1: NE555; DIP-8_W7.62mm

Connections:
+5V: R1.1, SW1.1 (A), U1.4, U1.8
GND: C1.1, C2.2, D1.1 (K), J1.2, J2.3, U1.1
unnamed: C1.2, U1.5
unnamed: C2.1, RV1.2, U1.2, U1.6
unnamed: D1.2 (A), R2.2
unnamed: J1.1, SW1.2 (B)
unnamed: J2.1, R2.1, U1.3
unnamed: R1.2, RV1.1, U1.7

Board: 2 copper layers, 27.9 x 27.9 mm, 10 parts (0 on the bottom side), 8 nets.

## KiCad design Four Power Outlet/Four Power Outlet.kicad_pcb

Parts:
D1, D2, D3, D4: LED; LED_D3.0mm
J1: Conn_01x02; JST_EH_B02B-EH-A_02x2.50mm_Straight
J2, J3, J4, J5: Conn_01x03; WQP-PJ301M-12_JACK-UPDATE
R1, R2, R3, R4: 330R; R_0805_HandSoldering
SW1, SW2, SW3, SW4: SW_SPDT; SPDT Through Hole Switch

Connections:
+5V: J1.2, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B)
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.1, J2.3, J3.3, J4.3, J5.3
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: J2.1, R1.1, SW1.1 (A)
unnamed: J3.1, R2.1, SW2.1 (A)
unnamed: J4.1, R3.1, SW3.1 (A)
unnamed: J5.1, R4.1, SW4.1 (A)

Board: 2 copper layers, 55.9 x 27.9 mm, 17 parts (0 on the bottom side), 10 nets.

## KiCad design NOR/NOR.kicad_pcb

Parts:
D1, D2, D3: LED; LED_D3.0mm
J1: Conn_01x02; JST_EH_B02B-EH-A_02x2.50mm_Straight
J2, J3, J4: Conn_01x03; WQP-PJ301M-12_JACK-UPDATE
Q1, Q2, Q3, Q4: 2N3904; SOT-23
R1, R3, R9: 33k; R_0805_HandSoldering
R2, R4: 33k; R_0805
R5, R6, R10: 330R; R_0805_HandSoldering
R7: 18k; R_0805_HandSoldering
R8: 4.7k; R_0805_HandSoldering

Connections:
+5V: D1.2 (A), D2.2 (A), J1.1, R8.1, R10.2
GND: J1.2, J2.3, J3.3, J4.3, Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (E), R7.2
unnamed: D1.1 (K), R5.2
unnamed: D2.1 (K), R6.2
unnamed: D3.1 (K), Q4.3 (C)
unnamed: D3.2 (A), R10.1
unnamed: J2.1, R1.2, R3.2
unnamed: J3.1, R2.2, R4.2
unnamed: J4.1, Q3.3 (C), R8.2, R9.2
unnamed: Q1.2 (B), R1.1
unnamed: Q1.3 (C), R5.1
unnamed: Q2.2 (B), R2.1
unnamed: Q2.3 (C), R6.1
unnamed: Q3.2 (B), R3.1, R4.1, R7.1
unnamed: Q4.2 (B), R9.1

Board: 2 copper layers, 27.9 x 27.9 mm, 21 parts (0 on the bottom side), 15 nets.

## Commit log

2021-03-20 Version 1 as sent to manufacturer
    Beginning of tracked changes.
2021-03-20 Created ToDo based on V1
    Version 1 sent off has been a middling success that has generated significant rework required (as expected).
    This should get something started.
